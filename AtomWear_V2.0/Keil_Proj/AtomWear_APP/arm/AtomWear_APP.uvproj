# Keil uVision project AtomWear_APP.uvproj, settings and files
target AtomWear_APP (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: AtomWear_APP +hex
  AfterMake: D:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o  .\_build\AtomWear_APP.bin .\_build\AtomWear_APP.axf
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\Include;..\..\..\Include\app_common;..\..\..\Include\ble;..\..\..\Include\ble\device_manager;..\..\..\Include\ble\ble_services;..\..\..\Include\s110;..\..\..\Include\sd_common;..\..\..\Include\sdk;..\..\..\Include\sensors;..\..\..\Include\oled;..\..\AtomWear_APP
  memory RVCT4: ROM 0x16000 size 0x20000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./: arm_startup_nrf51.s
    ../../../Source/templates/: system_nrf51.c
  group Source Code
    ../: main.c
    ../../../Source/twi_master/: twi_hw_master.c
    ../../../Source/xprintf/: xprintf.c
    ../../../Source/nrf_delay/: nrf_delay.c
    ../../../Source/: pwr_ctrl.c
  group Services
    ../../../Source/ble/ble_services/: ble_dis.c ble_bas.c ble_rscs.c ble_hts.c
  group Sensors
    ../../../Source/sensors/: bmp180.c mma8452q.c
  group StepCount
    ../../../Source/step_count/: step_count.c
  group OLED
    ../../../Source/OLED/: oled.c
  group INT Hander
    ../../../Source/interrupt_hander/: interrupt_hander.c
  group Libraries
    ../../../Source/ble/: ble_advdata.c ble_sensorsim.c ble_conn_params.c ble_error_log.c ble_debug_assert_handler.c
    ../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../Source/app_common/: app_timer.c app_trace.c pstorage.c crc16.c
    ../../../Source/sd_common/: softdevice_handler.c
    ../../../Source/simple_uart/: simple_uart.c
    ../../../Source/ble/device_manager/: device_manager_peripheral.c
