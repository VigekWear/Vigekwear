# Keil uVision project AtomWear_DFU.uvproj, settings and files
target Atom_Wear_DFU (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: AtomWear_DFU +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o  .\output\AtomWear_DFU.bin .\output\AtomWear_DFU.axf
  c flags: Optim=1
  c define: NRF51 BOARD_PCA10001
  c misc: --c99
  c include: .\Include
  memory RVCT4: ROM 0x28000 size 0x14000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group app
    ./: main.c
    ./Source/printf/: xprintf.c
    ./Source/: keil_arm_uv4.lnt
  group core
    ./Source/templates/arm/: arm_startup_nrf51.s
    ./Source/templates/: system_nrf51.c
    ./Source/nrf_delay/: nrf_delay.c
    ./Source/simple_uart/: simple_uart.c
  group ble_lib
    ./Source/ble_lib/: app_timer.c ble_advdata.c ble_conn_params.c ble_debug_assert_handler.c ble_error_log.c ble_flash.c ble_stack_handler.c
  group ble_srv
    ./Source/ble_serv/: ble_nus.c ble_srv_common.c ble_startup.c
  group dfu
    ./Source/flash_ctrl/: flash_ctrl.c
    ./Source/timer/: timer.c
    ./Source/dfu_ctrl/: dfu_ctrl.c
