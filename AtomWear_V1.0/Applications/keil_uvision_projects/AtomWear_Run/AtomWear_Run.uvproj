# Keil uVision project AtomWear_Run.uvproj, settings and files
target AtomWear_Run (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: AtomWear_Run_V_1_0 +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o  .\output\AtomWear_Run_V_1_0.bin .\output\AtomWear_Run_V_1_0.axf
  c flags: Optim=1
  c define: NRF51 BOARD_PCA10001 NRF51_DBG
  c misc: --c99
  c include: ..\..\..\Software\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ./: main.c
    ../../../Software/Source/: keil_arm_uv4.lnt
    ../../../Software/Source/xprintf/: xprintf.c
  group sys_lib
    ../../../Software/Source/templates/arm/: arm_startup_nrf51.s
    ../../../Software/Source/templates/: system_nrf51.c
    ../../../Software/Source/twi_master/: twi_hw_master.c
    ../../../Software/Source/simple_uart/: simple_uart.c
    ../../../Software/Source/nrf_delay/: nrf_delay.c
  group ble_lib
    ../../../Software/Source/ble_lib/: app_timer.c ble_advdata.c ble_conn_params.c ble_debug_assert_handler.c ble_error_log.c ble_flash.c ble_stack_handler.c
  group ble_serv
    ../../../Software/Source/ble_serv/: ble_nus.c ble_srv_common.c ble_startup.c
  group sensor_driver
    ../../../Software/Source/bmp180/: bmp180.c
    ../../../Software/Source/mma8452q/: mma8452q.c
    ../../../Software/Source/AK8963C/: ak8963.c
  group oled_display
    ../../../Software/Source/oled/: oled.c
  group step_count
    ../../../Software/Source/step_count/: step_count.c
  group INT_handle
    ../../../Software/Source/INT_handle/: INT_handle.c
  group sys_work_handle
    ../../../Software/Source/sys_work_handle/: flash_ctrl.c pwr_ctrl.c system_work_handle.c
  group sys_info_handle
    ../../../Software/Source/sys_info_storage/: system_info_storage.c
